# Repository LPaulson1985/EnviroTrack-Node

## KiCad design sensornode/sensornode_esp32/esp32_sensornode.kicad_pcb

Parts:
C1, C3, C4: 2.2u 10v; C_0603_1608Metric; LCSC C23630
C2, C5: 10u 10v; C_0603_1608Metric; LCSC C19702
J1: Conn_01x06_Female; PinHeader_1x06_P2.54mm_Vertical; LCSC C225481
J2: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J3: Micro_SD_Card; microSD_HC_Hirose_DM3D-SF
J4: USB_B_Mini; USB_Mini-B_Lumberg_2486_01_Horizontal; LCSC C46391
J5: Conn_01x02_Male; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J6, J7: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
Q1, Q2, Q3: NDS332P; SOT-23; LCSC C258217
Q4: MMDT2222A; SOT-363_SC-70-6; LCSC C96379
Q5: MMBT2222A; SOT-23; LCSC C151009
R1, R2, R11: 220R; R_0603_1608Metric; LCSC C22962
R3, R4, R7, R8, R9, R10, R12: 10k; R_0603_1608Metric; LCSC C25804
R5: 1.18k; R_0603_1608Metric; LCSC C402894
R6: 1.13k; R_0603_1608Metric; LCSC C308182
U1: ESP32-WROOM-32; LCSC C95209
U2: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering; LCSC C431940
U3: BQ24075; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm_ThermalVias; LCSC C15464
U4: CH330N; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C108996
U5: LM1117-3.3; SOT-223-3_TabPin2; LCSC C23984
U6: TPS3839DBZ; SOT-23; LCSC C96333

Connections:
+5V: C2.1, C4.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), R3.1, R4.1, R8.1, U3.5 (EN2), U3.10 (OUT), U3.11 (OUT), U5.3 (VI)
/BME280_MISO: U1.33 (IO21), U2.5 (SDO)
/BME280_MOSI: U1.31 (IO19), U2.3 (SDI)
/BME280_SCK: U1.30 (IO18), U2.4 (SCK)
/CLK: J3.5 (CLK), U1.20 (SCK/CLK)
/CMD: J3.3 (CMD), U1.19 (SCS/CMD)
/D0: J3.7 (DAT0), U1.21 (SDO/SD0)
/D1: J3.8 (DAT1), U1.22 (SDI/SD1)
/D2: J3.1 (DAT2), U1.17 (SHD/SD2)
/D3: J3.2 (DAT3/CD), U1.18 (SWP/SD3)
/EN: J1.5, U1.3 (EN), U6.2
/Enable_5V: U1.11 (IO26), U3.15 (SYSOFF)
/IO0: J1.4, U1.25 (IO0)
/IO4: J6.2, U1.26 (IO4)
/IO5: J6.4, U1.29 (IO5)
/IO12: J6.3, U1.14 (IO12)
/IO13: J6.5, U1.16 (IO13)
/IO14: J7.2, U1.13 (IO14)
/IO15: J7.4, U1.23 (IO15)
/IO23: J7.3, U1.37 (IO23)
/IO25: J7.5, U1.10 (IO25)
/RxD: J1.3, U1.34 (RXD0/IO3), U4.6 (TXD)
/SDS011_RxD: J2.6, U1.28 (IO17)
/SDS011_TxD: J2.7, U1.27 (IO16)
/TxD: J1.2, U1.35 (TXD0/IO1), U4.7 (RXD)
/USB_5V: C1.2, J4.1 (VBUS), U3.13 (IN), U4.5 (VCC)
/power_sao0: R2.2, U1.6 (IO34)
/power_sao1: R1.2, U1.7 (IO35)
/power_sds011: R11.2, U1.9 (IO33)
/~BME280_SS: U1.36 (IO22), U2.2 (CSB)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, J1.6, J2.5, J3.6 (VSS), J3.9 (SHIELD), J4.5 (GND), J4.6 (Shield), J5.1, J6.6, J7.6, Q4.1 (E1), Q4.4 (E2), Q5.3 (E), R5.2, R6.2, R7.2, R9.2, R10.2, R12.2, U1.1 (GND), U1.15 (GND), U1.38 (GND), U2.1 (GND), U2.7 (GND), U3.4 (~CE), U3.6 (EN1), U3.8 (VSS), U3.14 (TMR), U3.17 (PAD), U4.3 (GND), U5.1 (GND), U6.1
unnamed: C3.1, J5.2, U3.2 (BAT), U3.3 (BAT)
unnamed: J2.3, Q3.3 (D)
unnamed: J4.2 (D-), U4.2 (UD-)
unnamed: J4.3 (D+), U4.1 (UD+)
unnamed: J6.1, Q1.3 (D)
unnamed: J7.1, Q2.3 (D)
unnamed: Q1.1 (G), Q4.6 (C1), R3.2
unnamed: Q2.1 (G), Q4.3 (C2), R4.2
unnamed: Q3.1 (G), Q5.2 (C), R8.2
unnamed: Q4.2 (B1), R2.1, R7.1
unnamed: Q4.5 (B2), R1.1, R10.1
unnamed: Q5.1 (B), R11.1, R12.1
unnamed: R5.1, U3.12 (ILIM)
unnamed: R6.1, U3.16 (ISET)
unnamed: R9.1, U3.1 (TS)

Notes on the sheet:
SAO 0
SAO 1

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
Board: 2 copper layers, 70.0 x 33.0 mm, 35 parts (0 on the bottom side), 47 nets.

## Commit log

2020-03-31 update to latest board
2020-04-01 add lcsc part numbers
2020-04-01 position file
2020-04-01 add gerbers and drills
2020-04-05 create files for ordering
2020-04-11 update parts to use all 0603, move labels to be legible
2020-04-30 sds011 and bluetooth
2020-05-31 separate into functional areas
2020-05-31 get it almost compiling
2020-06-21 Blend wifimanager and bluetooth manager params
2020-06-23 state machine tweaks
2020-07-05 add comments for libs that are needed
2020-07-05 add comments for needed libraries
2020-07-05 update library list
2020-07-05 fix comments and move warmup code
2020-07-05 bug fixes
2020-07-05 more tweaks
